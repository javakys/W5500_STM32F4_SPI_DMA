# Keil uVision project Project.uvprojx, settings and files
target STM324x7I_EVAL (ARM-ADS)
  device: STM32F437II STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM324x7I_EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STM324x7I_EVAL, STM32F427X, USE_STDPERIPH_DRIVER
  c include: ..\;..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Utilities\STM32_EVAL\STM324x7I_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../: stm32f4xx_it.c main.c Retarget.c Serial.c
  group STM324xG_EVAL
    ../../../Utilities/STM32_EVAL/STM3240_41_G_EVAL/: stm324xg_eval_lcd.c stm324xg_eval.c stm324xg_eval_ioe.c stm324xg_eval_fsmc_sram.c
  group STM32F4xx_StdPeriph_Driver
    ../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_crc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_i2c.c stm32f4xx_sdio.c
  group CMSIS
    ../: system_stm32f4xx.c
  group MDK-ARM
    ../../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f427x.s startup_stm32f40xx.s
  group Ethernet
    ../Ethernet/: wizchip_conf.c socket.c
    ../Ethernet/W5500/: w5500.c
  group Application
    ../Application/: loopback.c
  group PlatformHandler
    ../PlatformHandler/: rcc_handler.c gpio_handler.c timer_handler.c uart_handler.c spi_handler.c dma_handler.c
target STM324xG_EVAL (ARM-ADS)
  device: STM32F401RE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x60000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F401_Test +hex
  AfterMake: .\HEX2BIN.exe  .\STM324xG_EVAL\STM32F401_Test.hex
  c flags: Optim=1 wLevel=2
  c define: USE_STM324xG_EVAL, STM32F40XX, USE_STDPERIPH_DRIVER
  c include: ..\;..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Utilities\STM32_EVAL\STM3240_41_G_EVAL;..\..\STM32F4xx_StdPeriph_Templates
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x18000
